# Keil uVision project DMA_test.uvprojx, settings and files
target DMA_test (6160000::V6.16::ARMCLANG)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: DMA_test +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USER/include;../USER/src/SDIO;../USER/src/LCD;../USER/src/LED;../USER/src/SRAM;../USER/src/DELAY;../USER/src/SYS;../USER/src/USART;../USER/src/KEY;../USER/src/MALLOC;../USER/src/NORFLASH;../USER/src/SPI;../USER/src;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../USER;../USER/src/lwip/src/include;../USER/src/lwip/arch;../USER/src/lwip;../USER/src/lwip/lwip_app;../USER/src/ETHERNET;../USER/src/GNSS;../USER/src/IMU;../USER/src/RTC;../USER/src/INS;../USER/src/TIMER;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../USER/src/FATFS/exfuns;..\USER\src\Qeuen
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c eth.c fsmc.c rtc.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_eth.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group USER
    ../USER/src/SDIO/: sdio_sdcard.c sd_data.c
    ../USER/src/lwip/: lwip_data.c
  group LCD
    ../USER/src/LCD/: lcd.c
  group LED
    ../USER/src/LED/: led.c
  group USMART
    ../USER/src/SRAM/: sram.c
  group GNSS
    ../USER/src/GNSS/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c gnss_solve.c
  group IMU
    ../USER/src/IMU/: analysis_data.c imu_data.c
  group SYS
    ../USER/src/sys/: sys.c
  group DELAY
    ../USER/src/delay/: delay.c
  group USART
    ../USER/src/USART/: usarts.c
  group KEY
    ../USER/src/KEY/: key.c
  group MALLOC
    ../USER/src/MALLOC/: malloc.c
  group NORFLASH
    ../USER/src/NORFLASH/: norflash.c
  group SPI
    ../USER/src/SPI/: spis.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/lwip/src/api
    ../USER/src/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/lwip/src/core
    ../USER/src/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../USER/src/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/lwip/src/netif
    ../USER/src/lwip/src/netif/: ethernet.c
  group Middlewares/lwip/arch
    ../USER/src/lwip/arch/: ethernetif.c lwip_comm.c
  group Middlewares/lwip/lwip_app
    ../USER/src/lwip/lwip_app/: lwip_demo.c
  group ETHERNETIF
    ../USER/src/ETHERNET/: ethernets.c
  group INS
    ../USER/src/INS/: dataPre.c INS.c navimain.c
  group TIMER
    ../USER/src/TIMER/: btim.c gtim.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: fatfs_platform.c bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Queue
    ../USER/src/Qeuen/: Qeuen.c
  group RTC
    ../USER/src/RTC/: rtcs.c
software components: CMSIS:CORE 5.6.0
